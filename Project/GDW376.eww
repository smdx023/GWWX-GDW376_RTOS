<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GDW376.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>GDW376</name>
    </batchDefinition>
  </batchBuild>
</workspace>


