# IAR project GDW376.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\APP\inc; ..\BSP\inc; ..\DLT104\inc; ..\DLT104\port; ..\uCOS-II\Ports; ..\uCOS-II\Source; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\APP; ..\BSP; ..\uCOS-II\Ports; ..\uCOS-II\Source; ..\Libraries\CMSIS\CM3\CoreSupport; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32F10x_StdPeriph_Driver\inc
  OBJCOPY.OOCOutputFile: GDW376.srec
  ILINK.IlinkOutputFile: GDW376.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\APP; ..\BSP; ..\uCOS-II\Ports; ..\uCOS-II\Source; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32F10x_StdPeriph_Driver\inc
  group APP
    ../APP/src/: Main.C store.c store_param.c task_dat_pro.c task_freeze.c task_meter.c task_ptl.c task_wlan.c
  group APP/old
    ../APP/src/: GDW376_AFN.c GDW376_CFG.c GDW376_DJPN.c GDW376_ERC.c GDW376_FUN.c GDW376_MeterCom.c GDW376_MMU.c GDW376_StatData.C GDW376_Table.c GDW376_Task.c
  group BSP
    ../BSP/src/: BSP_CFG.c I2C_FRAM.c MODEN_M590.c noway_m590.c printf.c Serial.c Setup.c SPI_Flash.c stm32f10x_it.c USERMATH.c
  group CPU
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group DLT104
    ../DLT104/DLT104/: dlt_104.c dlt_104_call.c dlt_104_elect.c dlt_104_init.c dlt_104_lib.c dlt_104_misc.c dlt_104_param.c dlt_104_soe.c dlt_104_time.c
  group DLT104/PORT
    ../DLT104/port/: dlt_104_port_com.c dlt_104_port_sys.c
  group uC/OS-II/Port
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
